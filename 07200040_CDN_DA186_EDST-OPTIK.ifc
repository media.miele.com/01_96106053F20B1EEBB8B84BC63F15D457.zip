Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-07-07T06:50:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jul 07 06:50:36 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{D232BE5E-B714-4360-9D01-A4E0D0138ADD}\ifc * Database version: 5507 * Database creation date: Wed Jul 07 06:50:35 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jul 07 06:50:35 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jul 07 06:50:35 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 28186050_CDN_7200040_DA186_EDST-OPTIK, 07200040_CDN_DA186_EDST-OPTIK:28186050_CDN_7200040_DA186_EDST-OPTIK:204978
In: Level 1
Type - Classification: ZWISCHENBAU DA (Uniformat); Material: z_Miele_Design_CLST, z_Miele_Design_Glass, Aluminum, z_Miele_Connection_Electric, z_Miele_Connection_ExhaustAir
Pset_BuildingElementProxyCommon - Reference: 28186050_CDN_7200040_DA186_EDST-OPTIK
Pset_ManufacturerTypeInformation - Manufacturer: Miele
